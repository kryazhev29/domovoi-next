<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project><path>$WS_DIR$\DomovoiNext.ewp</path></project>
  <project><path>$WS_DIR$\Bootloader\DomovoiBoot.ewp</path></project>
  <batchBuild/>
</workspace>
