# IAR project DomovoiNext_ASM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ASM_CRC; ASM_ID_HASH; ASM_FAST_KERNELS; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\STM32F10x\Include; Modules; STM32F10x_StdPeriph_Driver\inc; User; $PROJ_DIR$; STM32_USB-FS-Device_Driver\inc; USB-FS-CDC_User\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DOMOVOI_APP_HW=139
  OBJCOPY.OOCOutputFile: DomovoiNext.bin
  ILINK.IlinkOutputFile: DomovoiNext.out
  ILINK.IlinkIcfFile: settings\DomovoiNext2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: board.c main.c stm32_it.c
    Bootloader/: app_update.c boot_manual.c
  group CMSIS
    CMSIS/STM32F10x/Source/: startup_stm32f10x_md.s
    CMSIS/STM32F10x/: system_stm32f10x.c
  group Modules
    Modules/: adc_stm32f10x.c timers.c uart_stm32f10x.c wdt_stm32f10x.c comm_uart.c comm_at.c comm_power_v5.c comm_modem.c modem_slm336.c comm_channel.c comm_server.c comm_recover.c comm_info.c comm_call.c comm_sms.c comm_balance.c
    User/asm/: spi_stm32f10x_runtime.s usb_stm32f10x_runtime.s
  group STM32_USB-FS-Device_Driver
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USB-FS-CDC_User
    USB-FS-CDC_User/Src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group User
    User/: runtime_layout.c comm_timeouts.c indication.c outs.c prof.c user_str_fun.c wiegand.c
    User/asm/: sector_runtime_runtime.s expiry_runtime.s idclear_runtime.s photo_runtime.s idindex_runtime.s fw_service_runtime.s upload_runtime.s user_comm_runtime.s crc_runtime.s crc_asm.s id_hash_asm.s fast_kernels.s flash_w25_runtime.s memory_runtime.s sector_journal_runtime.s user_fun_runtime.s service_runtime.s
