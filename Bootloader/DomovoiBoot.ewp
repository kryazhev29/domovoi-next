# IAR project DomovoiBoot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; BOOTLOADER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\CMSIS\Include; ..\CMSIS\STM32F10x\Include; ..\Modules; ..\STM32F10x_StdPeriph_Driver\inc; ..\User; $PROJ_DIR$; ..\STM32_USB-FS-Device_Driver\inc; ..\USB-FS-CDC_User\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DomovoiNext.bin
  ILINK.IlinkOutputFile: DomovoiBoot.out
  ILINK.IlinkIcfFile: DomovoiBoot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
configuration Mini_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; BOOTLOADER; BOOT_BOARD_MINI; BOOT_HW_VERSION=11
configuration Modem_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; BOOTLOADER; BOOT_BOARD_MODEM; BOOT_HW_VERSION=140
  group (top)
    ./: boot_core.c boot_platform.c boot_main.c hw_config.c
    ../CMSIS/STM32F10x/Source/: startup_stm32f10x_md.s
    ../CMSIS/STM32F10x/: system_stm32f10x.c
    ../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../USB-FS-CDC_User/Src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_bkp.c
